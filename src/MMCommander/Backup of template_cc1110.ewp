# IAR project Backup of template_cc1110.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC1111F32.i51
  ICC8051.CCDefines: chip=1111
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: usb\class_cdc; usb\library; usb\others
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc1111F32.xcl
  group Headers
    ./: configuration.h constants.h crc_4b6b.h globals.h hal_cc8051.h hal_defs.h hal_types.h init.h interrupts.h ioCCxx10_bitdef.h txFilter.h
  group Sources
    ./: crc_4b6b.c init.c interrupts.c medtronicRF.c MMCommander.c txFilter.c
  group Sources/USB
    usb/others/: clock.c hal_board.c hal_int.c hal_mcu.c hal_uart_usb.c util_buffer.c
    usb/class_cdc/: usb_cdc_descriptor.s51 usb_cdc_hooks.c usb_firmware_library_config.c usb_uart.c
    usb/library/: usb_descriptor_parser.c usb_framework.c usb_interrupt.c usb_standard_requests.c usb_suspend.c
